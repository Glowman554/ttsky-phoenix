VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MACRO branding
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  FOREIGN branding 0 0 ;
  SIZE 62.110 BY 10.760 ;
  SYMMETRY X Y ;
  OBS
    LAYER met4 ;
    RECT 0 0 62.110 10.760 ;
  END
END branding
END LIBRARY
